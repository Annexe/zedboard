SRC_URI += "file://user_2018-01-21-13-04-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

